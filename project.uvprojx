# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, STM32F407xx, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c misc: --gnu
  c include: packages\LVGL-v8.3.11\src\extra\widgets\meter;..\..\..\components\libc\posix\ipc;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;..\libraries\HAL_Drivers\CMSIS\Include;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\draw\renesas;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\poll;board\CubeMX_Config\Inc;board\ports\fal;..\..\..\components\libc\cplusplus;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\extra\widgets\chart;board\lvgl\demo;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\extra\widgets\animimg;board\lvgl;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\FlashDB-v1.1.2\inc;..\..\..\components\finsh;applications;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\libs\gif;..\..\..\components\libc\compilers\common\include;packages\LVGL-v8.3.11\src\extra\layouts\flex;..\..\..\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\src\extra\themes\default;..\..\..\components\libc\posix\io\eventfd;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;packages\LVGL-v8.3.11\src\extra\layouts\grid;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\extra\libs\rlottie;board;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\extra\widgets\spinner;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;packages\LVGL-v8.3.11\src\draw\sw;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;..\..\..\include;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\others\msg;..\..\..\components\fal\inc;packages\LVGL-v8.3.11\src\extra\widgets\win;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\list;.;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\themes\mono;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\draw;board\ports\touch;..\..\..\components\drivers\spi\sfud\inc;..\libraries\HAL_Drivers;packages\LVGL-v8.3.11\src\misc;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\core;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\extra\libs\freetype;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\dfs\dfs_v1\include;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\draw\arm2d;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-v8.3.11\src\extra\widgets;packages\LVGL-v8.3.11\src\extra\layouts;board\ports\lcd;..\..\..\components\drivers\touch;board\ports;..\..\..\components\dfs\dfs_v1\filesystems\romfs;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\LVGL-v8.3.11\src\draw\sdl;..\libraries\HAL_Drivers\drivers;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\extra;..\libraries\HAL_Drivers\drivers\config;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\drv_flash;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\LVGL-v8.3.11\src\hal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: flashdb.c touch_calib.c touch_test.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    ../../../components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi-bit-ops.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/touch/: touch.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_f4.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_sdio.c drv_soft_i2c.c drv_soft_spi.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_filesystem.c spi_flash_init.c
    board/ports/fal/: fal_spi_flash_sfud_port.c
    board/ports/lcd/: drv_lcd_fsmc_16.c ili9341.c
    board/ports/touch/: drv_xpt2046.c
  group Fal
    ../../../components/fal/src/: fal_rtt.c fal.c fal_flash.c fal_partition.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh_file.c shell.c msh.c cmd.c
  group FlashDB
    packages/FlashDB-v1.1.2/samples/: tsdb_sample.c kvdb_type_blob_sample.c kvdb_basic_sample.c kvdb_type_string_sample.c
    packages/FlashDB-v1.1.2/src/: fdb_utils.c fdb_file.c fdb_kvdb.c fdb.c fdb_tsdb.c fdb_cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rng.c stm32f4xx_ll_fsmc.c stm32f4xx_hal.c stm32f4xx_hal_usart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sram.c stm32f4xx_hal_qspi.c stm32f4xx_hal_sd.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group LVGL
    packages/LVGL-v8.3.11/src/draw/: lv_draw_label.c lv_draw_triangle.c lv_draw.c lv_draw_mask.c lv_img_decoder.c lv_draw_img.c lv_img_cache.c lv_draw_arc.c lv_draw_line.c lv_draw_transform.c lv_draw_layer.c lv_draw_rect.c lv_img_buf.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_16.c lv_font_montserrat_36.c lv_font_montserrat_18.c lv_font_loader.c lv_font_montserrat_38.c lv_font_montserrat_42.c lv_font_montserrat_22.c lv_font_montserrat_28_compressed.c lv_font_montserrat_46.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_simsun_16_cjk.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_unscii_16.c lv_font_montserrat_48.c lv_font_montserrat_12_subpx.c lv_font_montserrat_30.c lv_font_montserrat_14.c lv_font_montserrat_28.c lv_font_montserrat_20.c lv_font_montserrat_44.c lv_font_fmt_txt.c lv_font_montserrat_40.c lv_font_montserrat_32.c lv_font_montserrat_12.c lv_font_montserrat_34.c lv_font_unscii_8.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_rect.c lv_draw_sw_arc.c lv_draw_sw_img.c lv_draw_sw_dither.c lv_draw_sw_letter.c lv_draw_sw_layer.c lv_draw_sw.c lv_draw_sw_transform.c lv_draw_sw_gradient.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_blend.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/widgets/: lv_btn.c lv_slider.c lv_switch.c lv_bar.c lv_table.c lv_checkbox.c lv_dropdown.c lv_line.c lv_textarea.c lv_img.c lv_label.c lv_arc.c lv_objx_templ.c lv_btnmatrix.c lv_roller.c lv_canvas.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_win32.c lv_fs_stdio.c
    packages/LVGL-v8.3.11/src/core/: lv_obj_style_gen.c lv_obj_draw.c lv_group.c lv_obj_class.c lv_indev_scroll.c lv_event.c lv_obj.c lv_theme.c lv_obj_pos.c lv_indev.c lv_obj_tree.c lv_disp.c lv_refr.c lv_obj_scroll.c lv_obj_style.c
    packages/LVGL-v8.3.11/src/misc/: lv_txt_ap.c lv_async.c lv_utils.c lv_mem.c lv_templ.c lv_math.c lv_color.c lv_gc.c lv_log.c lv_style.c lv_bidi.c lv_anim.c lv_tlsf.c lv_txt.c lv_lru.c lv_fs.c lv_printf.c lv_anim_timeline.c lv_style_gen.c lv_timer.c lv_ll.c lv_area.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_indev.c lv_hal_disp.c lv_hal_tick.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_gpu_nxp_pxp.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_line.c lv_vglite_buf.c lv_draw_vglite.c lv_vglite_utils.c lv_draw_vglite_arc.c lv_draw_vglite_rect.c lv_draw_vglite_blend.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_utils.c lv_draw_sdl_arc.c lv_draw_sdl_img.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_bg.c lv_draw_sdl_label.c lv_draw_sdl_polygon.c lv_draw_sdl_mask.c lv_draw_sdl.c lv_draw_sdl_texture_cache.c lv_draw_sdl_composite.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
  group LVGL-demo
    board/lvgl/demo/: lv_demo.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
